# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (6140001::V6.14.1::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx
  c include: .\Core;.\Drivers\STM32F4xx_StdPeriph_Driver\inc;.\FreeRTOS\include;.\Core\cJSON
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./Core/: main.c delay.c gpio.c interrupt.c system_stm32f4xx.c uart.c startup_stm32f407xx.s
    ./Core/cJSON/: cJSON.c
  group Driver
    ./Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_rcc.c
software components: CMSIS:CORE 5.4.0
